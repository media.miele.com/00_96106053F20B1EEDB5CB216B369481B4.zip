Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-04-04T09:57:30
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Apr 04 09:57:30 2023 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\a7ee306b-85f9-4597-aa38-a8e6f9e51c46\9dafa328-16cd-4acd-b406-0fc077c3ebd9\ifc * Database version: 5507 * Database creation date: Tue Apr 04 09:57:29 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Apr 04 09:57:30 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Apr 04 09:57:30 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12409490_D_PUR62W_MASW:28416255_D_12409490_PUR62W_MASW, (2)
In: Default
Type - Classification: WAND-DEKOR DA (Uniformat); Material: z_Miele_Design_Glass
Type - Pset_BuildingElementProxyCommon - Reference: 28416255_D_12409490_PUR62W_MASW
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 28416255_D_12409490_PUR62W_MASW
Material: z_Miele_Design_Glass, Aluminum, z_Miele_Design_OBSW, z_Miele_Design_Steel_Chrom, z_Miele_Connection_ExhaustAir, z_Miele_Connection_Electric, z_Miele_Design_CLST
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Width: 898 mm; Height: 62 mm; Depth: 500 mm
